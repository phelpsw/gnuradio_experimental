<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>variable</key>
<param><key>id</key><value>markfreq</value></param>
<param><key>value</key><value>2200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>spacefreq</value></param>
<param><key>value</key><value>1200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bitrate</value></param>
<param><key>value</key><value>1200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pi</value></param>
<param><key>value</key><value>3.14159265</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_centerfreq</value></param>
<param><key>value</key><value>min(markfreq,spacefreq)+symbol_deviation</value></param>
</block>
<block>
<key>gr_multiply_xx</key>
<param><key>id</key><value>gr_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_float_to_complex</key>
<param><key>id</key><value>gr_float_to_complex_0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_sig_source_x</key>
<param><key>id</key><value>gr_sig_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>sf_rate</value></param>
<param><key>waveform</key><value>gr.GR_SIN_WAVE</value></param>
<param><key>freq</key><value>-symbol_centerfreq</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sw_decim</value></param>
<param><key>value</key><value>int(sf_rate/bitrate/bit_oversampling)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bandwidth</value></param>
<param><key>value</key><value>sf_rate/sw_decim</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_freqdev</value></param>
<param><key>value</key><value>bandwidth/(2*pi*symbol_deviation)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bit_oversampling</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>alpha</value></param>
<param><key>value</key><value>1e-4</value></param>
</block>
<block>
<key>gr_quadrature_demod_cf</key>
<param><key>id</key><value>gr_quadrature_demod_cf_1</value></param>
<param><key>gain</key><value>symbol_freqdev</value></param>
</block>
<block>
<key>gr_sub_xx</key>
<param><key>id</key><value>gr_sub_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>num_inputs</key><value>2</value></param>
</block>
<block>
<key>gr_single_pole_iir_filter_xx</key>
<param><key>id</key><value>gr_single_pole_iir_filter_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>alpha</key><value>alpha</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_binary_slicer_fb</key>
<param><key>id</key><value>gr_binary_slicer_fb_0</value></param>
</block>
<block>
<key>gr_unpacked_to_packed_xx</key>
<param><key>id</key><value>gr_unpacked_to_packed_xx_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>bits_per_chunk</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>num_ports</key><value>1</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>Ruthlessly copied from: http://digilander.libero.it/iz2eeq/1200rx.py</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frequency_error</value></param>
<param><key>value</key><value>0.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mu</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain_mu</value></param>
<param><key>value</key><value>0.05</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>omega</value></param>
<param><key>value</key><value>bit_oversampling*(1+frequency_error)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain_omega</value></param>
<param><key>value</key><value>0.25 * gain_mu * gain_mu</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>omega_relative_limit</value></param>
<param><key>value</key><value>0.005</value></param>
</block>
<block>
<key>gr_clock_recovery_mm_xx</key>
<param><key>id</key><value>gr_clock_recovery_mm_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>omega</key><value>omega</value></param>
<param><key>gain_omega</key><value>gain_omega</value></param>
<param><key>mu</key><value>mu</value></param>
<param><key>gain_mu</key><value>gain_mu</value></param>
<param><key>omega_relative_limit</key><value>omega_relative_limit</value></param>
</block>
<block>
<key>gr_quadrature_demod_cf</key>
<param><key>id</key><value>gr_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>narrowband_fm_demod_gain</value></param>
</block>
<block>
<key>blks2_fm_deemph</key>
<param><key>id</key><value>blks2_fm_deemph_0</value></param>
<param><key>samp_rate</key><value>if_rate</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chan_taps</value></param>
<param><key>value</key><value>gr.firdes.low_pass(1, if_rate, 13e3, 4e3, gr.firdes.WIN_HANN)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>narrowband_fm_demod_gain</value></param>
<param><key>value</key><value>if_rate/(2*pi*narrowband_fm_deviation)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_deviation</value></param>
<param><key>value</key><value>abs(markfreq-spacefreq)/2.0</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>gr_file_sink_0</value></param>
<param><key>file</key><value>/sx/supernova/pwilliams/gnuradio_test/afsk/bit_fifo</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>if_rate</value></param>
<param><key>value</key><value>samp_rate</value></param>
</block>
<block>
<key>gr_fir_filter_xxx</key>
<param><key>id</key><value>gr_fir_filter_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>chan_taps</value></param>
</block>
<block>
<key>gr_fir_filter_xxx</key>
<param><key>id</key><value>gr_fir_filter_xxx_1</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>sw_decim</value></param>
<param><key>taps</key><value>lowpass_taps</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lowpass_taps</value></param>
<param><key>value</key><value>gr.firdes.low_pass(sw_decim,sf_rate,600,1e3,gr.firdes.WIN_HANN)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>narrowband_fm_deviation</value></param>
<param><key>value</key><value>3e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>200000</value></param>
</block>
<block>
<key>blks2_rational_resampler_xxx</key>
<param><key>id</key><value>blks2_rational_resampler_xxx_0</value></param>
<param><key>type</key><value>fff</value></param>
<param><key>decim</key><value>125</value></param>
<param><key>interp</key><value>96</value></param>
<param><key>taps</key><value>[]</value></param>
<param><key>fractional_bw</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sf_rate</value></param>
<param><key>value</key><value>if_rate*(96/125.0)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>144390000</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>gain0</key><value>52</value></param>
<param><key>ant0</key><value>RX2</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>xmlrpc_server</key>
<param><key>id</key><value>xmlrpc_server_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>addr</key><value>localhost</value></param>
<param><key>port</key><value>8080</value></param>
</block>
<connection><source_block_id>gr_fir_filter_xxx_0</source_block_id><sink_block_id>gr_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_quadrature_demod_cf_0</source_block_id><sink_block_id>blks2_fm_deemph_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_float_to_complex_0</source_block_id><sink_block_id>gr_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_sig_source_x_0</source_block_id><sink_block_id>gr_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_multiply_xx_0</source_block_id><sink_block_id>gr_fir_filter_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_fir_filter_xxx_1</source_block_id><sink_block_id>gr_quadrature_demod_cf_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_fm_deemph_0</source_block_id><sink_block_id>blks2_rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_quadrature_demod_cf_1</source_block_id><sink_block_id>gr_single_pole_iir_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_quadrature_demod_cf_1</source_block_id><sink_block_id>gr_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_single_pole_iir_filter_xx_0</source_block_id><sink_block_id>gr_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_sub_xx_0</source_block_id><sink_block_id>gr_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_clock_recovery_mm_xx_0</source_block_id><sink_block_id>gr_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_binary_slicer_fb_0</source_block_id><sink_block_id>gr_unpacked_to_packed_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_unpacked_to_packed_xx_0</source_block_id><sink_block_id>gr_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>gr_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_rational_resampler_xxx_0</source_block_id><sink_block_id>gr_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
